# Repository CXJ007/esp32-pro

## KiCad design esp32-pro.kicad_pcb

Parts:
AE1: Antenna; ANT-SMD_L3.1-W1.6
BOOT1: SW; SW-SMD_L4.0-W2.9-LS5.0
C1, C19, C23, C28, C30: 10uF; C_0402_1005Metric
C2, C5, C13, C14, C18, C21, C24, C29, C31: 1uF; C_0402_1005Metric
C3, C7, C9, C12, C15, C16, C17: 0.1uF; C_0402_1005Metric
C4, C6, C10, C11: TBD; C_0402_1005Metric
C8: 10nF; C_0402_1005Metric
C20, C26: 22uF; C_0402_1005Metric
C22, C27: 104; C_0402_1005Metric
C25: 22pF; C_0402_1005Metric
C32: 15pF; C_0402_1005Metric
D1: LED; LED_0805_2012Metric
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
J1, J2: Conn_01x08_Female; 8p_2.54
J3: DVP_24; FPC_24_0.5
L1: TBD; L_0402_1005Metric
L2: 2nH; L_0805_2012Metric
L3: 2.2uH; L2.2uh 2A
Q1, Q2: S8050; SOT-23
R1, R2, R5, R6, R9: 5.1K; R_0402_1005Metric
R3, R4, R11, R12, R14, R15, R16, R21, R22, R23, R24, R27: 10K; R_0402_1005Metric
R7: TBD; R_0402_1005Metric
R8: 499; R_0402_1005Metric
R10: 4.7K; R_0402_1005Metric
R13: 10; R_0402_1005Metric
R17: 24K; R_0402_1005Metric
R18, R26: 120K; R_0402_1005Metric
R19: 450K; R_0402_1005Metric
R20: 100k; R_0402_1005Metric
R25: 150K; R_0402_1005Metric
RES1: SW; SW-SMD_L4.0-W2.9-LS5.0
U1, U2: TYPE-C-31-M-12_母座; typec 12
U3: ESP32_S3; QFN-56_L7.0-W7.0-P0.40-TL-EP4.0
U4: CP2104; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U5: W25Q128
U6: ST7735
U7: Micro_SD_Card; Micro_SD
U8, U10: ME6221CM5G; SOT-23-5
U9: SY8089A; SOT-23-5
Y1: 40M; X322512MSB4S
m1, m2, m3, m4: M.n; M.2_Standoff_Card_Pad

Connections:
+3V3: C1.1, C3.1, C5.1, C8.1, C9.1, C16.1, C17.1, C18.1, C19.1, C21.1, C25.2, C26.1, C27.1, C28.1, C29.1, D2.1 (VDD), J1.7, J2.7, L2.1, L3.2, R3.1, R4.1, R14.1, R15.1, R16.1, R19.1, R27.1, U3.20 (VDD3P3_RTC), U3.46 (VDD3P3_CPU), U3.55 (VDDA), U3.56 (VDDA), U6.10 (VCC), U6.12 (LEDA), U7.4 (VDD), U8.1 (VIN), U8.3 (CE), U10.1 (VIN), U10.3 (CE)
+5V: C13.1, C20.1, C22.1, J1.8, J2.8, R9.2, U1.A4 (VBUS), U1.A9 (VBUS), U1.B4 (VBUS), U1.B9 (VBUS), U2.A4 (VBUS), U2.A9 (VBUS), U2.B4 (VBUS), U2.B9 (VBUS), U4.7 (REGIN), U4.8 (VBUS), U9.1 (EN), U9.4 (IN)
/+1V5: C23.1, C24.1, J3.10 (DVDD), R17.1, U8.5 (VOUT)
/+2V8: C30.1, C31.1, J3.4 (AVDD), J3.11 (DOVDD), R21.1, R23.1, R24.1, R25.1, U10.5 (VOUT)
/DTR: Q1.2 (E), R11.1, U4.23 (~DTR)
/EN: C2.1, Q2.3 (C), R3.2, RES1.1 (A), U3.4 (CHIP_PU)
/GPIO0: BOOT1.1 (A), Q1.3 (C), R4.2, U3.5 (GPIO0)
/GPIO1: U3.6 (GPIO1), U6.6 (RES)
/GPIO2: U3.7 (GPIO2), U6.7 (CS)
/GPIO3: U3.8 (GPIO3), U6.5 (RS)
/GPIO4: J3.3 (SDA), R24.2, U3.9 (GPIO4)
/GPIO5: J3.5 (SCL), R23.2, U3.10 (GPIO5)
/GPIO6: J3.7 (VSYNC), U3.11 (GPIO6)
/GPIO7: J3.9 (HREF), U3.12 (GPIO7)
/GPIO8: J3.12 (Y9), U3.13 (GPIO8)
/GPIO9: J3.13 (XCLK), U3.14 (GPIO9)
/GPIO10: J3.14 (Y8), U3.15 (GPIO10)
/GPIO11: J3.16 (Y7), U3.16 (GPIO11)
/GPIO12: C32.2, J3.17 (PCLK), U3.17 (GPIO12)
/GPIO13: J3.18 (Y6), U3.18 (GPIO13)
/GPIO14: J3.19 (Y2), U3.19 (GPIO14)
/GPIO15: J3.20 (Y5), U3.21 (XTAL_32K_P)
/GPIO16: J3.21 (Y3), U3.22 (XTAL_32K_N)
/GPIO17: J3.22 (Y4), U3.23 (GPIO17)
/GPIO18: U3.24 (GPIO18), U6.4 (SCL)
/GPIO21: U3.27 (GPIO21), U6.3 (SDA)
/GPIO26: J2.5, U3.28 (SPICS1)
/GPIO33: J1.5, U3.38 (GPIO33)
/GPIO34: J2.4, U3.39 (GPIO34)
/GPIO35: J1.4, U3.40 (GPIO35)
/GPIO36: J2.3, U3.41 (GPIO36)
/GPIO37: J1.3, U3.42 (GPIO37)
/GPIO38: R14.2, U3.43 (GPIO38), U7.3 (CMD)
/GPIO39: R15.2, U3.44 (MTCK), U7.5 (CLK)
/GPIO40: R16.2, U3.45 (MTDO), U7.7 (DAT0)
/GPIO41: J2.2, U3.47 (MTDI)
/GPIO42: J2.1, U3.48 (MTMS)
/GPIO45: J1.2, U3.51 (GPIO45)
/GPIO46: J1.1, U3.52 (GPIO46)
/GPIO47: J3.6 (RESET), R21.2, U3.37 (SPICLK_P)
/GPIO48: D2.4 (DIN), U3.36 (SPICLK_N)
/RTS: Q2.2 (E), R12.1, U4.19 (~RTS)
/SPICLK: U3.33 (SPICLK), U5.6 (CLK)
/SPICS0: U3.32 (SPICS0), U5.1 (/CS)
/SPID: U3.35 (SPID), U5.5 (DI/IO0)
/SPIHD: U3.30 (SPIHD), U5.7 (IO3)
/SPIQ: U3.34 (SPIQ), U5.2 (DO/IO1)
/SPIWP: U3.31 (SPIWP), U5.3 (IO2)
/U0RXD: U3.50 (U0RXD), U4.21 (TXD)
/U0TXD: R8.2, U4.20 (RXD)
/USB0_DN: U2.A7 (DN1), U2.B7 (DN2), U3.25 (GPIO19)
/USB0_DP: U2.A6 (DP1), U2.B6 (DP2), U3.26 (GPIO20)
/USB_DN: U1.A7 (DN1), U1.B7 (DN2), U4.4 (D-)
/USB_DP: U1.A6 (DP1), U1.B6 (DP2), U4.3 (D+)
/VDD_SPI: C12.1, C14.1, U3.29 (VDD_SPI), U5.8 (VCC)
GND: BOOT1.2 (B), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, D1.1 (K), D2.3 (VSS), J1.6, J2.6, J3.0, J3.2 (AGND), J3.15 (DGND), R1.1, R2.1, R5.2, R6.2, R13.2, R18.2, R20.2, R22.2, R26.2, RES1.2 (B), U1.0, U1.A1 (GND), U1.A12 (GND), U1.B1 (GND), U1.B12 (GND), U2.0, U2.A1 (GND), U2.A12 (GND), U2.B1 (GND), U2.B12 (GND), U3.57 (GND), U4.2 (GND), U4.25 (GND), U5.4 (GND), U6.8 (GND), U6.13 (GND), U7.6 (VSS), U7.10 (SHIELD), U8.2 (VSS), U9.2 (GND), U10.2 (VSS), Y1.2, m1.1, m2.1, m3.1, m4.1
unnamed: AE1.1 (A), C4.1, L1.1
unnamed: C6.1, L1.2, U3.1 (LNA_IN)
unnamed: C7.1, L2.2, U3.2 (VDD3P3), U3.3 (VDD3P3)
unnamed: C10.2, R7.1, Y1.3
unnamed: C11.2, U3.53 (XTAL_N), Y1.1
unnamed: C15.2, R10.1, U4.5 (VIO), U4.6 (VDD)
unnamed: C25.1, R19.2, R20.1, U9.5 (FB)
unnamed: D1.2 (A), R9.1
unnamed: J3.8 (PWDN), R22.1
unnamed: L3.1, U9.3 (LX)
unnamed: Q1.1 (B), R12.2
unnamed: Q2.1 (B), R11.2
unnamed: R1.2, U1.B5 (CC2)
unnamed: R2.2, U2.B5 (CC2)
unnamed: R5.1, U1.A5 (CC1)
unnamed: R6.1, U2.A5 (CC1)
unnamed: R7.2, U3.54 (XTAL_P)
unnamed: R8.1, U3.49 (U0TXD)
unnamed: R10.2, U4.9 (~RST)
unnamed: R13.1, U6.11 (LEDK)
unnamed: R17.2, R18.1, U8.4 (FB)
unnamed: R25.2, R26.1, U10.4 (FB)
unnamed: R27.2, U7.2 (CD/DAT3)

Notes on the sheet:
0.96TFT
AUTO-DOWMLOAD
USB-TTL
ESP32
camera
USB
RESET: 0:Reset 1:Normal
LED
ESP32­S3R2不建议cs1用于其他功能
KEY
POWER
Vout=0.6*(1+R1/R2)
PWDN: 0:Normal 1:Sleep
Vout=1.25*(1+R1/R2)

Board: 4 copper layers, 55.0 x 40.0 mm, 96 parts (18 on the bottom side), 79 nets.

Other parts of the board:
kibuzzard-62F65A14: G***; kibuzzard-62F65A14
kibuzzard-62F65EB3: G***; kibuzzard-62F65EB3
kibuzzard-62F65F77: G***; kibuzzard-62F65F77
kibuzzard-62F659AA: G***; kibuzzard-62F659AA
kibuzzard-62F659ED: G***; kibuzzard-62F659ED
kibuzzard-62F6591A: G***; kibuzzard-62F6591A
kibuzzard-62F6593A: G***; kibuzzard-62F6593A
kibuzzard-62F65989: G***; kibuzzard-62F65989
kibuzzard-62F66074: G***; kibuzzard-62F66074

## Commit log

2022-10-24 add readme
